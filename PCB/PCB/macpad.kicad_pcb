# Repository dercode163/MK-2

File README.md:

# macpad

The macpad is a 9 key macropad/keyboard with 2 EC11 style rotary encoders.

## Features:
- Sandwich style mount - 3D printable, BUT you need screws and heatset inserts
- EC11 Rotary encoders for rotational action AND they serve as switches/keys
- 9 fully programmable keys in a matrix

## CAD Model:
4 heatset inserts and 4 M3 screws are used to keep everything together

The model consists of a bottom case, a plate, and a bracket for the top, so the key switches themselves are less exposed.

There are also optional rotary encoder dials.

## PCB / Schematic
The PCB as well as the schematic is pictured below:

Schematic

PCB

## BOM:
Here is everything needed to make the macpad

- 9x Cherry MX Switches
- 9x DSA Keycaps
- 4x M3x5x4 Heatset inserts
- 4X M3x12mm SHCS Bolts
- 11x 1N4148 DO-35 Diodes.
- 2x EC11 Rotary Encoder
- 1x XIAO RP2040
- 1x Case (3 3D printed parts)
- 2x Rotary Encoder Dials (2 3D printed parts)
- 1x PCB

## KiCad design PCB/PCB/macpad.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9: SW_Push; SW_Cherry_MX_1.00u_PCB
SW14, SW15: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
U1: XIAO-RP2040-DIP

Connections:
+5V: U1.14 (VBUS)
COL0: SW1.1, SW2.1, SW3.1, SW15.S1, U1.3 (GPIO28/ADC2/A2)
COL1: SW4.1, SW5.1, SW6.1, U1.2 (GPIO27/ADC1/A1)
COL2: SW7.1, SW8.1, SW9.1, SW14.S1, U1.1 (GPIO26/ADC0/A0)
EC11_ONE_E: D10.1 (K), D11.1 (K), U1.7 (GPIO0/TX)
GND: SW14.C, SW15.C, U1.13 (GND)
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW15.S2
unnamed: D11.2 (A), SW14.S2
unnamed: SW14.B, U1.8 (GPIO1/RX)
unnamed: SW14.A, U1.9 (GPIO2/SCK)
unnamed: SW15.A, U1.11 (GPIO3/MOSI)
unnamed: SW15.B, U1.10 (GPIO4/MISO)
ROW1: D1.1 (K), D4.1 (K), D7.1 (K), U1.6 (GPIO7/SCL)
ROW2: D2.1 (K), D5.1 (K), D8.1 (K), U1.5 (GPIO6/SDA)
ROW3: D3.1 (K), D6.1 (K), D9.1 (K), U1.4 (GPIO29/ADC3/A3)

Board: 2 copper layers, 61.9 x 81.0 mm, 23 parts (12 on the bottom side), 23 nets.
